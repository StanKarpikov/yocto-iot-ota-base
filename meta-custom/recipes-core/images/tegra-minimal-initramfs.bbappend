PACKAGE_INSTALL:remove = " kernel-module-nvme "